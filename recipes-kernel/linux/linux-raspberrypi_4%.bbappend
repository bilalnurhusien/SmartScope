SUMMARY = "Configure Raspberry Pi kernel"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://mpu6050.cfg"
